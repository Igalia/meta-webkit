# The package in meta-oe lists x11 as required, but that
# is a lie: atkmm works just fine on Wayland-only systems.
REQUIRED_DISTRO_FEATURES = ""
