require libjxl.inc

BRANCH = "v0.8.x"
SRCREV = "c27d499263435ac77007174e0f1cf54557cff23a"
