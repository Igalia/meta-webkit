require libjxl.inc

