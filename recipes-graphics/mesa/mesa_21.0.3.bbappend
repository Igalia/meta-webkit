FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-gallium-dri-Make-YUV-formats-we-re-going-to-emulate-.patch"

