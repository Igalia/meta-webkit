# The package in meta-oe lists x11 as required, but that
# is a lie: pangomm works just fine on Wayland-only systems.
REQUIRED_DISTRO_FEATURES = ""
