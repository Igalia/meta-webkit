PACKAGECONFIG:append = " icu"
