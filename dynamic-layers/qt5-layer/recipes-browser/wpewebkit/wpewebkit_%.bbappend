# Enable QT bindings for WPE when meta-qt5 is in layer mix
#
PACKAGECONFIG_append = " qtwpe"
