# nooelint: oelint.vars.specific - toolchain-clang is specific from meta-clang
PACKAGECONFIG:remove:mipsarcho32:toolchain-clang = "jit"
