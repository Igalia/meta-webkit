RDEPENDS:packagegroup-wpewebkit-depends-tests:append = " \
    apache2 \
    apache2-scripts \
"
