IMAGE_INSTALL:append = " \
    apache2 \
    apache2-scripts \
"