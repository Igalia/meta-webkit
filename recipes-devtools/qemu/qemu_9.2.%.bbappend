FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-linux-user-Guard-RESOLVE_CACHED-flag-with-preprocess.patch"
