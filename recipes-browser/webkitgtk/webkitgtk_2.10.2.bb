require webkitgtk.inc

SRC_URI = "\
   http://www.webkitgtk.org/releases/webkitgtk-${PV}.tar.xz \
"

SRC_URI[md5sum] = "892e3077ad6c10c8233e7e8b5497cd7a"
SRC_URI[sha256sum] = "6adf497d24e36660037b84dfc1c53ac7f47bd4c459162290c49436eaa959a18f"
