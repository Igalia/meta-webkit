require webkitgtk.inc

SRC_URI = "\
   http://www.webkitgtk.org/releases/webkitgtk-${PV}.tar.xz \
"

SRC_URI[md5sum] = "252aad5319aa59d940b3d8161c5a9dc0"
SRC_URI[sha256sum] = "313682b23f03c457b28a7ef2d5bdb70a8174cca1d32e0a853fb36fa4dcf928a9"
