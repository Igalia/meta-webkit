require webkitgtk.inc

SRC_URI = "\
   http://www.webkitgtk.org/releases/webkitgtk-${PV}.tar.xz \
"

SRC_URI[md5sum] = "278d6c64f4673a506daf27556c124523"
SRC_URI[sha256sum] = "2b3ee0b2ea9bac82064d818085e09236d5fca97a5780d4c731b2f0400fb64052"
