require cog.inc

SRC_URI = "https://github.com/Igalia/${PN}/archive/v${PV}.tar.gz"

SRC_URI[md5sum] = "141b94b4cac9b70a9de3e1a2efc21019"
SRC_URI[sha256sum] = "7cefb6e045eaeb02ddb152cf283c1f35221110d0370a0fba7b76d4e96391279c"
